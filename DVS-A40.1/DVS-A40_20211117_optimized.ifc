Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DVS-A40_20211117.IFC
Time: 2021-11-17T12:38:51
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10400.00030.0009A (4)
In: Default Storey
SolidWorks Custom Properties - Description: Zahnscheibe DIN 6797 - 5 - A2K; Material: Stahl; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00050.0004A_M10 (2)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.011; Description: Sechskantmutter DIN 934 - M10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00055.0015A_M5 x 10 (2)
In: Default Storey
Material: Verzinkter Stahl
SolidWorks Custom Properties - Description: Linsenschraube DIN 7985 M5 x 10 - A2K; Material: Verzinkter Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00055.0017A (4)
In: Default Storey
SolidWorks Custom Properties - Description: Linsenschraube DIN 7985 - M5 x 20 - A2K; UNIT_OF_MEASURE: Description; Material: Stahl; Dicke: -; Weight: 0.005; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00055.0030A_M6 x 20 (2)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.007; Bezeichnung: Linsenschraube DIN 7985; Bezeichnung2: M6 x 20 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00055.0127A (2)
In: Default Storey
Material: 1.4301 (X5CrNi18-10)
SolidWorks Custom Properties - Material: 1.4301 (X5CrNi18-10); Dicke: -; Weight: 0.006; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: 10400.00081.0028A (4)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Description: Linsenkopfblechschraube 4,2 x 16 Form C; Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0225C (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: 1.5; Weight: 0.010; Bezeichnung: Distanzblech; Surface: verzinkt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0338C (6)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.620; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0347E (4)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.407; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0348A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.895; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0352B
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.069; Bezeichnung: Ventilatortragblech; Bezeichnung2: Flachdachsockel VDR.FDSL.DVV2 / DVV3; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0374B
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.071; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0560B
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.071; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.0644C
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,25; Weight: 3.973; Bezeichnung: Grundplatte; Bezeichnung2: Flachdachsockel VDR.FDSL.DVV2 / DVV3 H=900 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1163B
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 5.051; Bezeichnung: Sickenposition A30/40; ProjectNumber: 11209; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1164C
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 5059.45; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1165A (6)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.835; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1371A (2)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.022; Bezeichnung: Verschlusswinkel; Bezeichnung2: Durchgangsloch ø 4.9 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1397A (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.033; Bezeichnung: Verschlusswinkel; Bezeichnung2: Sechskantloch SW9; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1494D
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.561; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1495F
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.555; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.1496D_Tiefgezogen
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 4.875; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV-A30/A40 VTZ 2/3; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.90100.2668A (2)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.571; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.95000.0008F
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.49; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00200.95000.0008F_Warnhinweis
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.49; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-00700.95400.0012A (2)
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A40-00700.95400.0012A | Material: Hochdichte PE-Folie
DVS-A40-00700.95400.0012A

# IfcBuildingElementProxy: DVS-A40-10120.00110.0324A (6)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Hauptwarengruppe: Konstruktion; Unterwarengruppe: Dämmstoffzuschnitte; Länge: 500; Breite: 470; Höhe: -; Material: RAF-SE (50); Dicke: 50; Weight: 0.411; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.00100.0087A_4_DV A50-70
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.012; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.00500.0033B
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 2.00044245; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.08000.0026A
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.001; Bezeichnung: Verschlussstopfen VST M20; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.08000.0054A (3)
In: Default Storey
Material: PE niedrige/mittlere Dichte
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: PE niedrige/mittlere Dichte; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.08000.0059A (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.620 PA7001; Part Number: 50.620 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.08000.0061A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.220 PA7001; Part Number: 50.220 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10200.09000.0030A (4)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Beschreibung: Sicherungsscheibe; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00030.0018A_Default (2)
In: Default Storey
SolidWorks Custom Properties - DESIGN: KS Klemmscheibe für Wellen ohne Nut; REFERENCE: KS 5; SUPPLIER: SEEGER-ORBIS; TYPE: CATPART; Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Klemmscheibe M6; Bezeichnung2: DIN 99107-6; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00030.0025A
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: Stahl; OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00030.0032A (3)
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: 1.0226 (DX51D); OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
2 x DVS-A40-10400.00030.0032A | 1.0226 (DX51D)
DVS-A40-10400.00030.0032A

# IfcBuildingElementProxy: DVS-A40-10400.00040.0002A_M8
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00040.0018A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
2 x DVS-A40-10400.00040.0018A | Stahl
DVS-A40-10400.00040.0018A

# IfcBuildingElementProxy: DVS-A40-10400.00050.0003A_10400.00050.0003A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.006; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00050.0007A (2)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - IsToolboxPart: No; IsFastener: Yes; Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00055.0172A
In: Default Storey
SolidWorks Custom Properties - NN: DIN 913 (ISO 4026) - A2; NT: Hexagon socket set screws with flat point; NB: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; NBSYN: WUERTH $ARTNR. headless screw DIN 913 $NENN. $GUETE. $OBERFLAECHE.; LINA: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; ROWDESC: M8x40; ARTNR: 02618 40; MATERIAL: Stahl; GUETE: VORDEF; OBERFLAECHE: BLK; D: 8.000; D3: 6.466; P: 1.250; L: 40.000; DP: 5.500; S: 4.000; T: 5.000; SUPPLIER: WUERTH; ARTICLENO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; BOMINFO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.015; Bezeichnung: Gewindestift ISO 4026; Bezeichnung2: M8 x 40 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00055.0173A_Default (3)
In: Default Storey
SolidWorks Custom Properties - A: 2.400; ARTICLENO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; ARTNR: 00465 12; B: 9.600; BOMINFO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; CREATOR: CADENAS GmbH; D: 5.000; D3: 4.019; DK: 10.000; GUETE: 4.8; K: 3.800; L: 12.000; LINA: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; M: 5.300; MATERIAL: ST; NB: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; NBSYN: WUERTH $ARTNR. oval-head screw DIN 7985 $NENN. $GUETE. $OBERFLAECHE.; NN: DIN 7985 (ISO 7045) - 4.8 - zinc-plated (A2K), blue passivated; NT: Cross recessed raised cheese head screws; OBERFLAECHE: A2K; P: 0.800; R: 0.400; RF: 10.000; ROWDESC: M5x12; SUPPLIER: WUERTH; X: 2.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
2 x DVS-A40-10400.00055.0173A_Default | Stahl
DVS-A40-10400.00055.0173A_Default

# IfcBuildingElementProxy: DVS-A40-10400.00055.0182A (4)
In: Default Storey
Material: Edelstahl A2 / C1
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.003; Beschreibung: Dünnschaftschraube M5; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0001A (4)
In: Default Storey
Material: Stahl verzinkt/Stahl verzinkt, blau passiviert
SolidWorks Custom Properties - BEZEICHNUNG: Blindniete 4,8 x 10,0mm; Description: Blindniete 4,8 x 10,0mm; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.000; Bezeichnung2: Klemmbereich: 4.0 - 6.0 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0002A (198)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.001; Bezeichnung: Blindniet 3,0 x 6,0; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
72 x DVS-A40-10400.00100.0002A | Material: Stahl verzinkt/Stahl verzinkt, blau passiviert
126 x DVS-A40-10400.00100.0002A

# IfcBuildingElementProxy: DVS-A40-10400.00100.0016A (4)
In: Default Storey
SolidWorks Custom Properties - Description: RIVKLE®Einnietmutter M5; Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0021A (4)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0022A (2)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0029A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
2 x DVS-A40-10400.00100.0029A | Verzinkter Stahl
DVS-A40-10400.00100.0029A

# IfcBuildingElementProxy: DVS-A40-10400.00100.0041A (2)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0043A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.011; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0052A (2)
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.00100.0058A (4)
In: Default Storey
Material: Edelstahl A2 / C1
SolidWorks Custom Properties - Description: RIVKLE® Einnietmutter M5; Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.01000.0002A
In: Default Storey
SolidWorks Custom Properties - Material: Perspex (TM) GS Acrylic Cast Sheet; Dicke: -; Weight: 0.001; Bezeichnung: Sicherungsstopfen; Bezeichnung2: Bohrungen d=8 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.01020.0001A_1 (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.015; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.01020.0001A_2 (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.013; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A40-10400.01020.0001A_3 (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcElementAssembly: DVS-A40-00200.90100.1166B (3)
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A40-00200.90100.2809A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 17.11.2021; LastSaveName: wehnes; Material: -; Dicke: -; Weight: 4.875; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV-A30 / -A40, VTZ 2 / 3; Surface: -; Project: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A40-02020.20420.0003F_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A40-10200.00500.0040B
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A40-10400.01020.0001A_180° (2)
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Weight: 0.030; Bezeichnung: Scharnier; Bezeichnung2: 50 x 40 x 1.2, gebohrt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A40_20211117
In: Default Storey
SolidWorks Custom Properties - Maximale Kanalanschluss-Maße mm: 476 x 476; Rohranschluss (weitere Rohranschlüsse erhältlich) mm: 400; Mitgelieferte elastische Verbindung für Rohranschluss: Standard; Druckerhöhung zur Auslegung Pa: 130; Maximaler Volumenstrom zur Auslegung (75 %) m3/h: 1.838; Schalldruckpegel in 3 Meter Entfernung zur Auslegung (75 %) - Lp, A dB(A): 55; Schallleistungspegel an der Saugseite zur Auslegung (75 %) - Lw, A dB(A): 59; Druckerhöhung: 130; Maximaler Volumenstrom (100 %) m³/h: 2.450; Schalldruckpegel in 3 Meter Entfernung bei 100 % - Lp, A dB(A): 61; Schallleistungspegel an der Saugseite bei 100 % - Lw, A dB(A): 62; Schalldruckpegel in 3 Meter Entfernung bei 50 % - Lp, A dB(A): 46; Schallleistungspegel an der Saugseite bei 50 % - Lw, A dB (A): 55; Digitale Druckregelanzeige: Standard; instellbare Druckerhöhung Pa: 5 - 300*; Antriebstechnik: EC-Motor; Reparaturschalter: Standard; Anschlussspannung: 230 V / 50 Hz; Maximaler Nennstrom A: 2,00; Leistungsaufnahme zur Auslegung (75 %) Watt: 216; SFP zur Auslegung (75 %) W/m³/h: 0,118; Maximale Leistungsaufnahme (Motoranlauf) Watt: 459; Maximale Lufttemperatur °C: 40; Schutzart des Motors IP: 54; Motorschutz: intern; Störmeldung: Standard; Herausnehmbare Schalldämmungskulisse: Standard; Wärmebrückenfreie Konstruktion (S=50 mm, WLG 035): Standard; Gewicht des Gerätes (Sockel) kg: 65 (41); Material (Gehäuse): verzinktes Stahlblech
PSet_Mass_Property - Mass Measure: 40.9802; Area Measure: 15.0501 m2; Volume Measure: 0.0754136 m3
